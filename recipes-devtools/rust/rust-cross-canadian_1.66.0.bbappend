require rust-cross-canadian-new.inc
