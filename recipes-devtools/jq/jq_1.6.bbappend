# Build jq statically
EXTRA_OECONF:append_class-native = " --enable-all-static "
