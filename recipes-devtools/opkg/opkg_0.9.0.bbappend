
DEPENDS:append:wrynose = " xz xz-native"
