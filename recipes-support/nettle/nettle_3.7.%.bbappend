EXTRA_OECONF:append = " --enable-mini-gmp"
