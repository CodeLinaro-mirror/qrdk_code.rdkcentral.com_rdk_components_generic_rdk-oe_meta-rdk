PACKAGECONFIG:remove_kirkstone = "gnutls"
PACKAGECONFIG:class-native:remove_kirkstone = "gnutls"
PACKAGECONFIG:append_kirkstone = " openssl"
PACKAGECONFIG:class-native:append_kirkstone = " openssl"
